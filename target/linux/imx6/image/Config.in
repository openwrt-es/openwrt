## target/linux/imx6/image/Config.in
```kconfig
config IMX6_SD_BOOT_PARTSIZE
	int "Boot (SD Card) filesystem partition size (in MB)"
	depends on TARGET_imx6
	default 20
```
